# Repository hydazz/iasis (continued)

## KiCad design hardware/boards/iasis/iasis.kicad_pcb (continued)

Schematic: controller-panel.kicad_sch, Port indicators and physical confirmation

Parts:
C1170, C1171, C1172, C1173, C1174, C1175, C1176, C1177, C1178: 100n; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
D1170, D1171, D1172, D1173, D1174, D1175: SK6812SIDE-A; OPSCO_SK6812SIDE-A; MPN SK6812SIDE-A; LCSC C5378721
R1171: 33; R_0402_1005Metric; MPN 0402WGF330JTCE; LCSC C25105
R1172, R1185: 100k; R_0402_1005Metric; MPN 0402WGF1003TCE; LCSC C25741
R1173, R1181: 10k; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
SW1171: PTS645SL50SMTR92LFS; SW_SPST_PTS645Sx43SMTR92; MPN PTS645SL50SMTR92LFS; LCSC C221877
U1171: SN74AHCT1G125DBVR; SOT-23-5; MPN SN74AHCT1G125DBVR; LCSC C7484
U1172: TCA6408ARGTR; VQFN-16-1EP_3x3mm_P0.5mm_EP1.45x1.45mm; MPN TCA6408ARGTR; LCSC C181499

Connections:
3V3_AON: C1172.1, R1173.1, R1181.1, U1172.14 (V_{CCP}), U1172.15 (V_{CCI}); also elsewhere on the board
5V_LOGIC: C1170.1, C1171.1, C1174.1, C1175.1, C1176.1, C1177.1, C1178.1, D1170.2 (VDD), D1171.2 (VDD), D1172.2 (VDD), D1173.2 (VDD), D1174.2 (VDD), D1175.2 (VDD), U1171.5 (VCC); also elsewhere on the board
/Indicators and confirmation/LED_DIN0: D1170.1 (DIN), R1171.2
/Indicators and confirmation/LED_DIN1: D1170.3 (DOUT), D1175.1 (DIN)
/Indicators and confirmation/LED_DIN2: D1174.1 (DIN), D1175.3 (DOUT)
/Indicators and confirmation/LED_DIN3: D1173.1 (DIN), D1174.3 (DOUT)
/Indicators and confirmation/LED_DIN4: D1172.1 (DIN), D1173.3 (DOUT)
/Indicators and confirmation/LED_DIN5: D1171.1 (DIN), D1172.3 (DOUT)
/Indicators and confirmation/LED_DRIVE: R1171.1, U1171.4
CH224_PG_N: U1172.9 (P6); also elsewhere on the board
CONFIRM_N: C1173.1, R1181.2, SW1171.1; also elsewhere on the board
EXP_RESET_N: R1172.1, U1172.1 (~RESET); also elsewhere on the board
EXT_ORIENT: R1185.1, U1172.4 (P2); also elsewhere on the board
GND: C1170.2, C1171.2, C1172.2, C1173.2, C1174.2, C1175.2, C1176.2, C1177.2, C1178.2, D1170.4 (GND), D1171.4 (GND), D1172.4 (GND), D1173.4 (GND), D1174.4 (GND), D1175.4 (GND), R1172.2, R1185.2, SW1171.2, U1171.1, U1171.3 (GND), U1172.6 (GND), U1172.16 (ADDR), U1172.17 (EPAD); also elsewhere on the board
HUB_RUN: R1173.2, U1172.7 (P4); also elsewhere on the board
INPUT_PROTECT_FAULT_N: U1172.8 (P5); also elsewhere on the board
LED_DATA: U1171.2; also elsewhere on the board
MCU_I2C_SCL: U1172.12 (SCL); also elsewhere on the board
MCU_I2C_SDA: U1172.13 (SDA); also elsewhere on the board
SHIFT_CLK: U1172.3 (P1); also elsewhere on the board
SHIFT_DATA: U1172.2 (P0); also elsewhere on the board
SHIFT_LATCH: U1172.5 (P3); also elsewhere on the board
SIDE_PRESENT_N: U1172.10 (P7); also elsewhere on the board

Notes on the sheet:
D1170 is the Iasis status indicator; D1171-D1175 are targets 1-5 (GRB, 800 kHz). U1172 controls host orientation and HUB_RUN; reset leaves HUB_RUN high and EXT_ORIENT low. The host VBUS monitor is independent of this expander and of MCU firmware. Confirmation is a deliberate firmware action; attach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
Port indicators and physical confirmation

Schematic: hub.kicad_sch, USB 3.2 Gen 2 hub — target ports 1–5 and the controller

Parts:
C201, C202: 33p C0G; C_0402_1005Metric; MPN 0402CG330J500NT; LCSC C1562
C203, C204, C205, C206, C207, C208, C209, C210, C212, C213, C214, C215, C216, C217, C218, C219, C220, C224, C226: 100n; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
C211, C221: 10u 10V; C_0603_1608Metric; MPN CL10A106KP8NNNC; LCSC C19702
C222, C223: 100n 16V X7R; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
R201: 12k 1%; R_0402_1005Metric; MPN 0402WGF1202TCE; LCSC C25752
R202: 10k 1%; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
R203, R204, R205, R206, R232: 200k 1%; R_0402_1005Metric; MPN 0402WGF2003TCE; LCSC C25764
R207, R208, R209, R210, R211, R212, R213, R214, R215: 10k; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
R217, R218, R219, R220, R221, R222, R223, R224, R225, R226, R227, R228, R229, R230, R231: 100k; R_0402_1005Metric; MPN 0402WGF1003TCE; LCSC C25741
U201: USB7206CT/KDX; VQFN-100-1EP_12x12mm_P0.4mm_EP8x8mm_ThermalVias; MPN USB7206CT/KDX; LCSC C3210691
U204: SN74AUP1G08DCKR; SOT-353_SC-70-5; MPN SN74AUP1G08DCKR; LCSC C507223
U205: SN74LVC1G32DBVR; SOT-23-5; MPN SN74LVC1G32DBVR; LCSC C10096
Y201: X322525MSB4SI; Crystal_SMD_3225-4Pin_3.2x2.5mm; MPN X322525MSB4SI; LCSC C13740

Connections:
3V3_AON: C203.1, C204.1, C205.1, C206.1, C207.1, C208.1, C209.1, C210.1, C211.1, C224.1, C226.1, R207.1, R208.1, R209.1, R210.1, R211.1, R212.1, R213.1, R214.1, R215.1, U201.26 (VDD33), U201.43 (VDD33), U201.53 (VDD33), U201.62 (VDD33), U201.67 (VDD33), U201.79 (VDD33), U201.88 (VDD33), U201.99 (VDD33), U204.5 (VCC), U205.5 (VCC); also elsewhere on the board
/USB hub — ports 1–5/CFG_BC_EN: R206.1, U201.70 (SPI_D0/CFG_BC_EN/PF22)
/USB hub — ports 1–5/CFG_NON_REM: R205.1, U201.69 (SPI_CE_N/CFG_NON_REM/PF20)
/USB hub — ports 1–5/CFG_STRAP1: R202.1, U201.21 (CFG_STRAP1)
/USB hub — ports 1–5/CFG_STRAP2: R203.1, U201.22 (CFG_STRAP2)
/USB hub — ports 1–5/CFG_STRAP3: R204.1, U201.23 (CFG_STRAP3)
/USB hub — ports 1–5/HUB_RESET_N: U201.1 (RESET_N), U204.4
/USB hub — ports 1–5/PF3: R221.1, U201.44 (PF3/I2S_SDI)
/USB hub — ports 1–5/PF4: R222.1, U201.45 (PF4/I2S_SDO)
/USB hub — ports 1–5/PF5: R223.1, U201.46 (PF5/I2S_SCK)
/USB hub — ports 1–5/PF6: R224.1, U201.47 (PF6/I2S_LRCK)
/USB hub — ports 1–5/PF7: R225.1, U201.48 (PF7/I2S_MCLK)
/USB hub — ports 1–5/PF18: R226.1, U201.61 (PF18/MSTR_I2C_CLK)
/USB hub — ports 1–5/PF19: R230.1, U201.66 (PF19/MIC_DET)
/USB hub — ports 1–5/PF31: R227.1, U201.3 (PF31/MSTR_I2C_DATA)
/USB hub — ports 1–5/PRT_CTL1: R207.2, U201.60 (PF17/PRT_CTL1)
/USB hub — ports 1–5/PRT_CTL2: R208.2, U201.59 (PF16/PRT_CTL2)
/USB hub — ports 1–5/PRT_CTL3: R209.2, U201.58 (PF15/PRT_CTL3)
/USB hub — ports 1–5/PRT_CTL4: R210.2, U201.57 (PF14/PRT_CTL4)
/USB hub — ports 1–5/PRT_CTL5: R211.2, U201.56 (PF13/PRT_CTL5)
/USB hub — ports 1–5/PRT_CTL6: R212.2, U201.77 (PF28/PRT_CTL6)
/USB hub — ports 1–5/RBIAS: R201.1, U201.100 (RBIAS)
/USB hub — ports 1–5/SPI_CLK: R217.1, U201.68 (SPI_CLK/PF21)
/USB hub — ports 1–5/SPI_D1: R218.1, U201.71 (SPI_D1/PF23)
/USB hub — ports 1–5/SPI_D2: R219.1, U201.72 (SPI_D2/PF24)
/USB hub — ports 1–5/SPI_D3: R220.1, U201.73 (SPI_D3/PF25)
/USB hub — ports 1–5/TEST1: R213.2, U201.63 (TEST1)
/USB hub — ports 1–5/TEST2: R214.2, U201.64 (TEST2)
/USB hub — ports 1–5/TEST3: R215.2, U201.65 (TEST3)
/USB hub — ports 1–5/UP_TX_N: C223.1, U201.91 (USB3UP_TXDP)
/USB hub — ports 1–5/UP_TX_P: C222.1, U201.92 (USB3UP_TXDM)
/USB hub — ports 1–5/XI: C201.1, U201.98 (XTALI/CLK_IN), Y201.1
/USB hub — ports 1–5/XO: C202.1, U201.97 (XTALO), Y201.3
AON_RESET_N: U204.1; also elsewhere on the board
CM5_HOST: U205.2; also elsewhere on the board
EXT_VBUS: R231.1; also elsewhere on the board
GND: C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, C213.2, C214.2, C215.2, C216.2, C217.2, C218.2, C219.2, C220.2, C221.2, C224.2, C226.2, R201.2, R202.2, R203.2, R204.2, R205.2, R206.2, R217.2, R218.2, R219.2, R220.2, R221.2, R222.2, R223.2, R224.2, R225.2, R226.2, R227.2, R228.2, R229.2, R230.2, R232.2, U201.24 (TESTEN), U201.101 (VSS), U204.3 (GND), U205.3 (GND), Y201.2 (G), Y201.4 (G); also elsewhere on the board
HUB_D_N: U201.90 (USB2UP_DM); also elsewhere on the board
HUB_D_P: U201.89 (USB2UP_DP); also elsewhere on the board
HUB_RUN: U204.2; also elsewhere on the board
HUB_RX_N: U201.94 (USB3UP_RXDP); also elsewhere on the board
HUB_RX_P: U201.95 (USB3UP_RXDM); also elsewhere on the board
HUB_SCL: R228.1, U201.75 (PF26/SLV_I2C_CLK); also elsewhere on the board
HUB_SDA: R229.1, U201.76 (PF27/SLV_I2C_DATA); also elsewhere on the board
HUB_TX_N: C223.2; also elsewhere on the board
HUB_TX_P: C222.2; also elsewhere on the board
HUB_UP_VBUS: U201.2 (PF30/VBUS_MON_UP), U205.4
MCU_USB_D_N: U201.41 (USB2DN_DM6/PRT_DIS_M6); also elsewhere on the board
MCU_USB_D_P: U201.42 (USB2DN_DP6/PRT_DIS_P6); also elsewhere on the board
unnamed: R231.2, R232.1, U205.1
P1_RX_N: U201.11 (USB3DN_RXDM1); also elsewhere on the board
P1_RX_P: U201.10 (USB3DN_RXDP1); also elsewhere on the board
P1_TX_RAW_N: U201.8 (USB3DN_TXDM1); also elsewhere on the board
P1_TX_RAW_P: U201.7 (USB3DN_TXDP1); also elsewhere on the board
P1_USB2_D_N: U201.6 (USB2DN_DM1/PRT_DIS_M1); also elsewhere on the board
P1_USB2_D_P: U201.5 (USB2DN_DP1/PRT_DIS_P1); also elsewhere on the board
P2_RX_N: U201.20 (USB3DN_RXDM2); also elsewhere on the board
P2_RX_P: U201.19 (USB3DN_RXDP2); also elsewhere on the board
P2_TX_RAW_N: U201.17 (USB3DN_TXDM2); also elsewhere on the board
P2_TX_RAW_P: U201.16 (USB3DN_TXDP2); also elsewhere on the board
P2_USB2_D_N: U201.15 (USB2DN_DM2/PRT_DIS_M2); also elsewhere on the board
P2_USB2_D_P: U201.14 (USB2DN_DP2/PRT_DIS_P2); also elsewhere on the board
P3_RX_N: U201.33 (USB3DN_RXDM3); also elsewhere on the board
P3_RX_P: U201.32 (USB3DN_RXDP3); also elsewhere on the board
P3_TX_RAW_N: U201.30 (USB3DN_TXDM3); also elsewhere on the board
P3_TX_RAW_P: U201.29 (USB3DN_TXDP3); also elsewhere on the board
P3_USB2_D_N: U201.28 (USB2DN_DM3/PRT_DIS_M3); also elsewhere on the board
P3_USB2_D_P: U201.27 (USB2DN_DP3/PRT_DIS_P3); also elsewhere on the board
P4_RX_N: U201.40 (USB3DN_RXDM4); also elsewhere on the board
P4_RX_P: U201.39 (USB3DN_RXDP4); also elsewhere on the board
P4_TX_RAW_N: U201.37 (USB3DN_TXDM4); also elsewhere on the board
P4_TX_RAW_P: U201.36 (USB3DN_TXDP4); also elsewhere on the board
P4_USB2_D_N: U201.35 (USB2DN_DM4/PRT_DIS_M4); also elsewhere on the board
P4_USB2_D_P: U201.34 (USB2DN_DP4/PRT_DIS_P4); also elsewhere on the board
P5_RX_N: U201.87 (USB3DN_RXDM5); also elsewhere on the board
P5_RX_P: U201.86 (USB3DN_RXDP5); also elsewhere on the board
P5_TX_RAW_N: U201.84 (USB3DN_TXDM5); also elsewhere on the board
P5_TX_RAW_P: U201.83 (USB3DN_TXDP5); also elsewhere on the board
P5_USB2_D_N: U201.82 (USB2DN_DM5/PRT_DIS_M5); also elsewhere on the board
P5_USB2_D_P: U201.81 (USB2DN_DP5/PRT_DIS_P5); also elsewhere on the board
VCORE: C212.1, C213.1, C214.1, C215.1, C216.1, C217.1, C218.1, C219.1, C220.1, C221.1, U201.9 (VCORE), U201.18 (VCORE), U201.25 (VCORE), U201.31 (VCORE), U201.38 (VCORE), U201.55 (VCORE), U201.78 (VCORE), U201.85 (VCORE), U201.93 (VCORE); also elsewhere on the board

Notes on the sheet:
USB 3.2 Gen 2 hub — target ports 1–5 and the controller
Configuration 3: CFG_STRAP1 10k; CFG_STRAP2/3, NON_REM and BC_EN 200k pull-downs. Internal ROM boot; all ports removable; battery charging detection off. HUB_SCL/SDA stay low during reset for autonomous attachment. RESET_N = AON_RESET_N AND HUB_RUN; HUB_RUN has a pull-up. The selected host reaches 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

Schematic: host-port.kicad_sch, Host port — front USB-C to an external computer

Parts:
C902, C905: 1u 10V X7R; C_0603_1608Metric; MPN CGA0603X7R105K100JT; LCSC C22399625
C903: 100n 50V X7R; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
C904, C908, C909, C910: 100n; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
C906, C907: 220p C0G; C_0402_1005Metric; MPN 0402CG221J500NT; LCSC C39122
J901: 1054500101; USB_C_Receptacle_Molex_105450-0101; MPN 1054500101; LCSC C134092
Q901, Q902: 2N7002; SOT-23; MPN 2N7002; LCSC C8545
R901, R905, R907: 10k; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
R902, R903: 4.7k; R_0402_1005Metric; MPN 0402WGF4701TCE; LCSC C25900
R904, R906: 100k; R_0402_1005Metric; MPN 0402WGF1003TCE; LCSC C25741
U901, U902: TPD4E02B04DQAR; USON-10_2.5x1.0mm_P0.5mm; MPN TPD4E02B04DQAR; LCSC C106794
U903, U906: HD3SS3212IRKSR; DHVQFN-20-1EP_2.5x4.5mm_P0.5mm_EP1x3mm; MPN HD3SS3212IRKSR; LCSC C544517
U904: TPD6S300ARUKR; WQFN-20-1EP_3x3mm_P0.4mm_EP1.7x1.7mm_ThermalVias; MPN TPD6S300ARUKR; LCSC C2876380
U905: FUSB302BMPX; WQFN-14-1EP_2.5x2.5mm_P0.5mm_EP1.45x1.45mm; MPN FUSB302BMPX; LCSC C132291
U907: TMUX1511RSVR; UQFN-16_1.8x2.6mm_P0.4mm; MPN TMUX1511RSVR; LCSC C2673275

Connections:
3V3_AON: C902.1, C904.1, C905.1, C908.1, C909.1, C910.1, R901.1, R902.1, R903.1, R904.1, R907.1, U903.6 (VCC), U904.10 (VPWR), U905.3 (VDD), U905.4 (VDD), U905.12 (VCONN), U905.13 (VCONN), U906.6 (VCC), U907.16 (VDD); also elsewhere on the board
/Host port/CC1_CONN: J901.A5 (CC1), U904.4 (C_CC1), U904.7 (RPD_G1)
/Host port/CC1_PD: C906.1, U904.12 (CC1), U905.10 (CC1), U905.11 (CC1)
/Host port/CC2_CONN: J901.B5 (CC2), U904.5 (C_CC2), U904.6 (RPD_G2)
/Host port/CC2_PD: C907.1, U904.11 (CC2), U905.1 (CC2), U905.14 (CC2)
/Host port/CM5_HOST_N: Q901.3 (D), R904.2, U907.11 (SEL3), U907.15 (SEL4)
/Host port/D_CONN_N: J901.A7 (D-), J901.B7 (D-), U904.2 (C_SBU2)
/Host port/D_CONN_P: J901.A6 (D+), J901.B6 (D+), U904.1 (C_SBU1)
/Host port/EXT_PD_INT_N: R901.2, U905.5 (INT_N)
/Host port/RX1_N: J901.B10 (RX1-), U901.5 (D2-), U901.6 (NC), U903.12 (C1N)
/Host port/RX1_P: J901.B11 (RX1+), U901.4 (D2+), U901.7 (NC), U903.13 (C1P)
/Host port/RX2_N: J901.A10 (RX2-), U902.5 (D2-), U902.6 (NC), U903.16 (B1N)
/Host port/RX2_P: J901.A11 (RX2+), U902.4 (D2+), U902.7 (NC), U903.17 (B1P)
/Host port/TX1_N: J901.A2 (TX1+), U901.2 (D1-), U901.9 (NC), U903.14 (C0N)
/Host port/TX1_P: J901.A3 (TX1-), U901.1 (D1+), U901.10 (NC), U903.15 (C0P)
/Host port/TX2_N: J901.B2 (TX2+), U902.2 (D1-), U902.9 (NC), U903.18 (B0N)
/Host port/TX2_P: J901.B3 (TX2-), U902.1 (D1+), U902.10 (NC), U903.19 (B0P)
/Host port/VBIAS: C903.1, U904.3 (VBIAS)
CM5_HOST: Q901.1 (G), Q902.3 (D), R905.1, U906.9 (SEL), U907.1 (SEL1), U907.4 (SEL2); also elsewhere on the board
EXT_D_N: U904.14 (SBU2), U907.14 (S4)
EXT_D_P: U904.15 (SBU1), U907.10 (S3)
EXT_ORIENT: U903.9 (SEL); also elsewhere on the board
EXT_RX_N: U903.8 (A1N), U906.18 (B0N)
EXT_RX_P: U903.7 (A1P), U906.19 (B0P)
EXT_SCL: R902.2, U905.6 (SCL); also elsewhere on the board
EXT_SDA: R903.2, U905.7 (SDA); also elsewhere on the board
EXT_TX_N: U903.4 (A0N), U906.16 (B1N)
EXT_TX_P: U903.3 (A0P), U906.17 (B1P)
EXT_VBUS: J901.A4 (VBUS), J901.A9 (VBUS), J901.B4 (VBUS), J901.B9 (VBUS), U905.2 (VBUS); also elsewhere on the board
GND: C902.2, C903.2, C904.2, C905.2, C906.2, C907.2, C908.2, C909.2, C910.2, J901.A1 (GND), J901.A12 (GND), J901.B1 (GND), J901.B12 (GND), J901.SH (SHIELD), Q901.2 (S), Q902.2 (S), R905.2, R906.2, U901.3 (GND), U901.8 (GND), U902.3 (GND), U902.8 (GND), U903.2 (OE_N), U903.5 (GND), U903.11 (GND), U903.20 (GND), U903.21 (EP), U904.8 (GND), U904.13 (GND), U904.16 (GND), U904.17 (GND), U904.18 (GND), U904.19 (D2), U904.20 (D1), U904.21 (GND), U905.8 (GND), U905.9 (GND), U905.15 (GND), U906.2 (OE_N), U906.5 (GND), U906.11 (GND), U906.20 (GND), U906.21 (EP), U907.8 (GND); also elsewhere on the board
HOST_EXT: Q902.1 (G), R906.1; also elsewhere on the board
HUB_D_N: U907.3 (D1), U907.13 (D4); also elsewhere on the board
HUB_D_P: U907.6 (D2), U907.9 (D3); also elsewhere on the board
HUB_RX_N: U906.4 (A0N); also elsewhere on the board
HUB_RX_P: U906.3 (A0P); also elsewhere on the board
HUB_TX_N: U906.8 (A1N); also elsewhere on the board
HUB_TX_P: U906.7 (A1P); also elsewhere on the board
SIDE_D_N: U907.2 (S1); also elsewhere on the board
SIDE_D_P: U907.5 (S2); also elsewhere on the board
SIDE_PRESENT_N: R907.2; also elsewhere on the board
SIDE_RX_N: U906.15 (C0P); also elsewhere on the board
SIDE_RX_P: U906.14 (C0N); also elsewhere on the board
SIDE_TX_N: U906.13 (C1P); also elsewhere on the board
SIDE_TX_P: U906.12 (C1N); also elsewhere on the board

Notes on the sheet:
CC / USB 2 protection and sink PD
Host port — front USB-C to an external computer
RPD_G1/G2 tie to C_CC1/C_CC2: the dead-battery Rd asks an unpowered host port for VBUS. The FUSB302B keeps its Rd and is polled on TCA9548 channel 5; INT_N has a pull-up only. VCONN is unused. FLT is open: a sink cannot remove the host's VBUS, and the TPD6S300A isolates CC and D+/D- itself. D1/D2 s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
EXT_ORIENT=1: CC1 / TX1 / RX1. EXT_ORIENT=0: CC2 / TX2 / RX2. Set orientation from the host CC termination. USB2 is available before firmware runs. The host supplies RX lane AC coupling; the hub supplies TX lane AC coupling. Logic is host-powered; the hub VBUS detect follows its own 3.3 V supply. T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
Host select (every build): CM5_HOST high routes the hub upstream to the CM5 side link; low, or HOST_EXT set, routes it to J901.

Schematic: power-select.kicad_sch, Host power and target budget

Parts:
C1903: 47n 50V X7R; C_0603_1608Metric; MPN CL10B473KB8NNNC; LCSC C1622
C1904: 2.2u 25V X5R; C_0603_1608Metric; MPN CL10A225KA8NNNC; LCSC C57895
C1905: 22u 16V X7R; C_1210_3225Metric; MPN CL32B226KOJNNNE; LCSC C55530
C1906, C1911, C1913: 100n; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
C1912: 10u 16V X5R; C_0805_2012Metric; MPN CL21A106KAYNNNE; LCSC C15850
Q1911, Q1912: 2N7002; SOT-23; MPN 2N7002; LCSC C8545
R1906: 64.9k 0.1%; R_0402_1005Metric; MPN RT0402BRD0764K9L; LCSC C852880
R1907: 10k 1%; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
R1908: 20k 1%; R_0402_1005Metric; MPN 0402WGF2002TCE; LCSC C25765
R1909: 1k 1%; R_0402_1005Metric; MPN 0402WGF1001TCE; LCSC C11702
R1910: 100; R_0402_1005Metric; MPN 0402WGF1000TCE; LCSC C25076
R1911, R1915, R1917: 100k; R_0402_1005Metric; MPN 0402WGF1003TCE; LCSC C25741
R1912: 10k; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
R1913: 200k 1%; R_0402_1005Metric; MPN 0402WGF2003TCE; LCSC C25764
R1914: 68k 1%; R_0402_1005Metric; MPN 0402WGF6802TCE; LCSC C36871
R1916: 22k 1%; R_0402_1005Metric; MPN 0402WGF2202TCE; LCSC C25768
U1901: AP22653W6-7; SOT-23-6; MPN AP22653W6-7; LCSC C2158037
U1902: TPS259470ARPWR; TI_RPW0010A; MPN TPS259470ARPWR; LCSC C3662799

Connections:
3V3_AON: R1912.1; also elsewhere on the board
5V_LOGIC: C1905.1, C1906.1, C1911.1, U1901.1 (IN), U1902.6 (OUT); also elsewhere on the board
/Host power and target budget/HOST_BUDGET_ILIM: R1913.1, R1914.1, R1916.1, U1901.5 (ILIM)
/Host power and target budget/LOGIC_DVDT: R1910.1, U1902.7 (DVDT)
/Host power and target budget/LOGIC_EN: R1906.2, R1907.1, U1902.1 (EN_UVLO)
/Host power and target budget/LOGIC_ILIM: R1909.1, U1902.9 (ILM)
EXT_VBUS: C1904.1, R1906.1, U1902.5 (IN); also elsewhere on the board
GND: C1903.2, C1904.2, C1905.2, C1906.2, C1911.2, C1912.2, C1913.2, Q1911.2 (S), Q1912.2 (S), R1908.2, R1909.2, R1911.2, R1913.2, R1915.2, R1917.2, U1901.2 (GND), U1902.8 (GND); also elsewhere on the board
HOST_BUDGET_22K: Q1912.1 (G), R1917.1; also elsewhere on the board
HOST_BUDGET_68K: Q1911.1 (G), R1915.1; also elsewhere on the board
HOST_BUDGET_FAULT_N: R1912.2, U1901.4 (FAULT_N); also elsewhere on the board
HOST_TARGET_5V: C1912.1, C1913.1, U1901.6 (OUT); also elsewhere on the board
HOST_TARGET_EN: R1911.1, U1901.3 (EN); also elsewhere on the board
LOGIC_OVLO: R1907.2, R1908.1, U1902.2 (OVLO); also elsewhere on the board
unnamed: C1903.1, R1910.2
unnamed: Q1911.3 (D), R1914.2
unnamed: Q1912.3 (D), R1916.2

Notes on the sheet:
Host power — autonomous logic and bounded target allocation
68k / 22k selections: 00 ≤0.17 A; 10 ≤0.55 A; 01 ≤1.45 A; 11 ≤1.89 A. Budget the worst tier plus logic consumption. No automatic 3 A assumption. Target aggregate defaults off; the hub and MCU remain powered upstream of it.
Logic starts from host VBUS. The MCU enables target power only after the upstream current allowance is known.

Schematic: ports.kicad_sch, Five independent target channels

Notes on the sheet:
Five independent target channels

Schematic: controller-bus.kicad_sch, Management buses

Parts:
C1131, C1132: 100n; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
J1131: SM04B-SRSS-TB; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal; MPN SM04B-SRSS-TB(LF)(SN); LCSC C160404
J1132: UART TX debug; SolderPads_1x03_P2.54mm
R1131, R1132: 2.2k; R_0402_1005Metric; MPN 0402WGF2201TCE; LCSC C25879
R1133: 10k; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
R1135, R1136, R1137: 4.7k; R_0402_1005Metric; MPN 0402WGF4701TCE; LCSC C25900
U1131: TCA9548ARGER; Texas_RGE0024C_VQFN-24-1EP_4x4mm_P0.5mm_EP2.1x2.1mm; MPN TCA9548ARGER; LCSC C555456
U1132: SN74AUP1G08DCKR; SOT-353_SC-70-5; MPN SN74AUP1G08DCKR; LCSC C507223

Connections:
3V3_AON: C1131.1, C1132.1, J1131.2, R1131.1, R1132.1, R1133.1, R1136.1, R1137.1, U1131.21 (VCC), U1132.5 (VCC); also elsewhere on the board
AON_RESET_N: U1132.1; also elsewhere on the board
AUX_SCL: J1131.4, R1137.2, U1131.17 (SC7); also elsewhere on the board
AUX_SDA: J1131.3, R1136.2, U1131.16 (SD7); also elsewhere on the board
EXT_SCL: U1131.13 (SC5); also elsewhere on the board
EXT_SDA: U1131.12 (SD5); also elsewhere on the board
GND: C1131.2, C1132.2, J1131.1, J1131.MP (MountPin), J1132.2, R1135.2, U1131.9 (GND), U1131.18 (A2), U1131.22 (A0), U1131.23 (A1), U1132.3 (GND); also elsewhere on the board
HUB_SCL: U1131.15 (SC6); also elsewhere on the board
HUB_SDA: U1131.14 (SD6); also elsewhere on the board
MCU_I2C_SCL: R1132.2, U1131.19 (SCL); also elsewhere on the board
MCU_I2C_SDA: R1131.2, U1131.20 (SDA); also elsewhere on the board
MCU_UART_TX: J1132.3; also elsewhere on the board
MUX_RUN: R1135.1, U1132.2; also elsewhere on the board
P1_SCL: U1131.2 (SC0); also elsewhere on the board
P1_SDA: U1131.1 (SD0); also elsewhere on the board
P2_SCL: U1131.4 (SC1); also elsewhere on the board
P2_SDA: U1131.3 (SD1); also elsewhere on the board
P3_SCL: U1131.6 (SC2); also elsewhere on the board
P3_SDA: U1131.5 (SD2); also elsewhere on the board
P4_SCL: U1131.8 (SC3); also elsewhere on the board
P4_SDA: U1131.7 (SD3); also elsewhere on the board
P5_SCL: U1131.11 (SC4); also elsewhere on the board
P5_SDA: U1131.10 (SD4); also elsewhere on the board
TCA_RESET_N: R1133.2, U1131.24 (~RESET), U1132.4

Notes on the sheet:
J1132 is the 3.3 V UART log output: NC / GND / TX solder pads. Power the board from its host port before using UART; do not connect an adapter supply.
MUX_RUN is held low until firmware releases the mux. Physical RESET also deselects every mux channel. Expander reset remains independent on GPIO32.
Management buses
I2C mux address 0x70; select one channel at a time. Channels 0-4 are targets 1-5; channel 5 is the host CC controller. Channel 6 reaches the hub strap/status pins without pull-ups; autonomous ROM boot takes priority. Channel 7 is the charging-input control and optional display bus.

Schematic: target-port.kicad_sch, Target port — one circuit used five times

Notes on the sheet:
Only per-port signals cross this page. 3V3_AON, 5V_LOGIC, HOST_TARGET_5V and HV_CHARGE are explicit common rails inside their circuit sheets.
Target port — one circuit used five times
