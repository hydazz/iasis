# Repository hydazz/iasis (continued)

## KiCad design hardware/boards/iasis/iasis.kicad_pcb (continued)

Schematic: target-data.kicad_sch, USB-C data and PD

Parts:
C401, C402: 100n 25V X7R; C_0402_1005Metric; MPN CL05B104KB54PNC; LCSC C307331
C403, C408, C410: 100n; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
C404, C409: 1u 10V X7R; C_0603_1608Metric; MPN CGA0603X7R105K100JT; LCSC C22399625
C405: 100n 50V X7R; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
C406, C407: 220p C0G; C_0402_1005Metric; MPN 0402CG221J500NT; LCSC C39122
C411: 22u 16V X7R; C_1210_3225Metric; MPN CL32B226KOJNNNE; LCSC C55530
J401: 1054500101; USB_C_Receptacle_Molex_105450-0101; MPN 1054500101; LCSC C134092
R401, R402, R403: 10k; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
R404, R405: 4.7k; R_0402_1005Metric; MPN 0402WGF4701TCE; LCSC C25900
U401: HD3SS3212IRKSR; DHVQFN-20-1EP_2.5x4.5mm_P0.5mm_EP1x3mm; MPN HD3SS3212IRKSR; LCSC C544517
U402, U403: TPD4E02B04DQAR; USON-10_2.5x1.0mm_P0.5mm; MPN TPD4E02B04DQAR; LCSC C106794
U404: TPD6S300ARUKR; WQFN-20-1EP_3x3mm_P0.4mm_EP1.7x1.7mm_ThermalVias; MPN TPD6S300ARUKR; LCSC C2876380
U405: FUSB302BMPX; WQFN-14-1EP_2.5x2.5mm_P0.5mm_EP1.45x1.45mm; MPN FUSB302BMPX; LCSC C132291

Connections:
3V3_AON: C403.1, C404.1, C408.1, C409.1, R401.1, R402.1, R403.1, R404.1, R405.1, U401.6 (VCC), U404.10 (VPWR), U405.3 (VDD), U405.4 (VDD); also elsewhere on the board
5V_LOGIC: C410.1, C411.1, U405.12 (VCONN), U405.13 (VCONN); also elsewhere on the board
/Target ports/Target 1/USB-C data and PD/CC1_CONN: J401.A5 (CC1), U404.4 (C_CC1)
/Target ports/Target 1/USB-C data and PD/CC1_PD: C406.1, U404.12 (CC1), U405.10 (CC1), U405.11 (CC1)
/Target ports/Target 1/USB-C data and PD/CC2_CONN: J401.B5 (CC2), U404.5 (C_CC2)
/Target ports/Target 1/USB-C data and PD/CC2_PD: C407.1, U404.11 (CC2), U405.1 (CC2), U405.14 (CC2)
/Target ports/Target 1/USB-C data and PD/RX1_N: J401.B10 (RX1-), U401.12 (C1N), U402.5 (D2-), U402.6 (NC)
/Target ports/Target 1/USB-C data and PD/RX1_P: J401.B11 (RX1+), U401.13 (C1P), U402.4 (D2+), U402.7 (NC)
/Target ports/Target 1/USB-C data and PD/RX2_N: J401.A10 (RX2-), U401.16 (B1N), U403.5 (D2-), U403.6 (NC)
/Target ports/Target 1/USB-C data and PD/RX2_P: J401.A11 (RX2+), U401.17 (B1P), U403.4 (D2+), U403.7 (NC)
/Target ports/Target 1/USB-C data and PD/TX1_N: J401.A2 (TX1+), U401.14 (C0N), U402.2 (D1-), U402.9 (NC)
/Target ports/Target 1/USB-C data and PD/TX1_P: J401.A3 (TX1-), U401.15 (C0P), U402.1 (D1+), U402.10 (NC)
/Target ports/Target 1/USB-C data and PD/TX2_N: J401.B2 (TX2+), U401.18 (B0N), U403.2 (D1-), U403.9 (NC)
/Target ports/Target 1/USB-C data and PD/TX2_P: J401.B3 (TX2-), U401.19 (B0P), U403.1 (D1+), U403.10 (NC)
/Target ports/Target 1/USB-C data and PD/TX_N: C402.2, U401.3 (A0P)
/Target ports/Target 1/USB-C data and PD/TX_P: C401.2, U401.4 (A0N)
/Target ports/Target 1/USB-C data and PD/USB2_D_CONN_N: J401.A7 (D-), J401.B7 (D-), U404.2 (C_SBU2)
/Target ports/Target 1/USB-C data and PD/USB2_D_CONN_P: J401.A6 (D+), J401.B6 (D+), U404.1 (C_SBU1)
/Target ports/Target 1/USB-C data and PD/VBIAS: C405.1, U404.3 (VBIAS)
GND: C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, C410.2, C411.2, J401.A1 (GND), J401.A12 (GND), J401.B1 (GND), J401.B12 (GND), J401.SH (SHIELD), U401.2 (OE_N), U401.5 (GND), U401.11 (GND), U401.20 (GND), U401.21 (EP), U402.3 (GND), U402.8 (GND), U403.3 (GND), U403.8 (GND), U404.6 (RPD_G2), U404.7 (RPD_G1), U404.8 (GND), U404.13 (GND), U404.16 (GND), U404.17 (GND), U404.18 (GND), U404.19 (D2), U404.20 (D1), U404.21 (GND), U405.8 (GND), U405.9 (GND), U405.15 (GND); also elsewhere on the board
P1_CC_FAULT_N: R402.2, U404.9 (~FLT); also elsewhere on the board
P1_ORIENTATION: R401.2, U401.9 (SEL); also elsewhere on the board
P1_PD_IRQ_N: R403.2, U405.5 (INT_N); also elsewhere on the board
P1_RX_N: U401.7 (A1P); also elsewhere on the board
P1_RX_P: U401.8 (A1N); also elsewhere on the board
P1_SCL: R404.2, U405.6 (SCL); also elsewhere on the board
P1_SDA: R405.2, U405.7 (SDA); also elsewhere on the board
P1_TX_RAW_N: C402.1; also elsewhere on the board
P1_TX_RAW_P: C401.1; also elsewhere on the board
P1_USB2_D_N: U404.14 (SBU2); also elsewhere on the board
P1_USB2_D_P: U404.15 (SBU1); also elsewhere on the board
P1_VBUS: J401.A4 (VBUS), J401.A9 (VBUS), J401.B4 (VBUS), J401.B9 (VBUS), U405.2 (VBUS); also elsewhere on the board

Parts of its further copies:
C501, C502, C601, C602, C701, C702, C801, C802: 100n 25V X7R; C_0402_1005Metric; MPN CL05B104KB54PNC; LCSC C307331
C503, C508, C510, C603, C608, C610, C703, C708, C710, C803, C808, C810: 100n; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
C504, C509, C604, C609, C704, C709, C804, C809: 1u 10V X7R; C_0603_1608Metric; MPN CGA0603X7R105K100JT; LCSC C22399625
C505, C605, C705, C805: 100n 50V X7R; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
C506, C507, C606, C607, C706, C707, C806, C807: 220p C0G; C_0402_1005Metric; MPN 0402CG221J500NT; LCSC C39122
C511, C611, C711, C811: 22u 16V X7R; C_1210_3225Metric; MPN CL32B226KOJNNNE; LCSC C55530
J501, J601, J701, J801: 1054500101; USB_C_Receptacle_Molex_105450-0101; MPN 1054500101; LCSC C134092
R501, R502, R503, R601, R602, R603, R701, R702, R703, R801, R802, R803: 10k; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
R504, R505, R604, R605, R704, R705, R804, R805: 4.7k; R_0402_1005Metric; MPN 0402WGF4701TCE; LCSC C25900
U501, U601, U701, U801: HD3SS3212IRKSR; DHVQFN-20-1EP_2.5x4.5mm_P0.5mm_EP1x3mm; MPN HD3SS3212IRKSR; LCSC C544517
U502, U503, U602, U603, U702, U703, U802, U803: TPD4E02B04DQAR; USON-10_2.5x1.0mm_P0.5mm; MPN TPD4E02B04DQAR; LCSC C106794
U504, U604, U704, U804: TPD6S300ARUKR; WQFN-20-1EP_3x3mm_P0.4mm_EP1.7x1.7mm_ThermalVias; MPN TPD6S300ARUKR; LCSC C2876380
U505, U605, U705, U805: FUSB302BMPX; WQFN-14-1EP_2.5x2.5mm_P0.5mm_EP1.45x1.45mm; MPN FUSB302BMPX; LCSC C132291

Connections of its further copies:
3V3_AON: C503.1, C504.1, C508.1, C509.1, C603.1, C604.1, C608.1, C609.1, C703.1, C704.1, C708.1, C709.1, C803.1, C804.1, C808.1, C809.1, R501.1, R502.1, R503.1, R504.1, R505.1, R601.1, R602.1, R603.1, R604.1, R605.1, R701.1, R702.1, R703.1, R704.1, R705.1, R801.1, R802.1, R803.1, R804.1, R805.1, U501.6 (VCC), U504.10 (VPWR), U505.3 (VDD), U505.4 (VDD), U601.6 (VCC), U604.10 (VPWR), U605.3 (VDD), U605.4 (VDD), U701.6 (VCC), U704.10 (VPWR), U705.3 (VDD), U705.4 (VDD), U801.6 (VCC), U804.10 (VPWR), U805.3 (VDD), U805.4 (VDD); also elsewhere on the board
5V_LOGIC: C510.1, C511.1, C610.1, C611.1, C710.1, C711.1, C810.1, C811.1, U505.12 (VCONN), U505.13 (VCONN), U605.12 (VCONN), U605.13 (VCONN), U705.12 (VCONN), U705.13 (VCONN), U805.12 (VCONN), U805.13 (VCONN); also elsewhere on the board
/Target ports/Target 2/USB-C data and PD/CC1_CONN: J501.A5 (CC1), U504.4 (C_CC1)
/Target ports/Target 2/USB-C data and PD/CC1_PD: C506.1, U504.12 (CC1), U505.10 (CC1), U505.11 (CC1)
/Target ports/Target 2/USB-C data and PD/CC2_CONN: J501.B5 (CC2), U504.5 (C_CC2)
/Target ports/Target 2/USB-C data and PD/CC2_PD: C507.1, U504.11 (CC2), U505.1 (CC2), U505.14 (CC2)
/Target ports/Target 2/USB-C data and PD/RX1_N: J501.B10 (RX1-), U501.12 (C1N), U502.5 (D2-), U502.6 (NC)
/Target ports/Target 2/USB-C data and PD/RX1_P: J501.B11 (RX1+), U501.13 (C1P), U502.4 (D2+), U502.7 (NC)
/Target ports/Target 2/USB-C data and PD/RX2_N: J501.A10 (RX2-), U501.16 (B1N), U503.5 (D2-), U503.6 (NC)
/Target ports/Target 2/USB-C data and PD/RX2_P: J501.A11 (RX2+), U501.17 (B1P), U503.4 (D2+), U503.7 (NC)
/Target ports/Target 2/USB-C data and PD/TX1_N: J501.A2 (TX1+), U501.14 (C0N), U502.2 (D1-), U502.9 (NC)
/Target ports/Target 2/USB-C data and PD/TX1_P: J501.A3 (TX1-), U501.15 (C0P), U502.1 (D1+), U502.10 (NC)
/Target ports/Target 2/USB-C data and PD/TX2_N: J501.B2 (TX2+), U501.18 (B0N), U503.2 (D1-), U503.9 (NC)
/Target ports/Target 2/USB-C data and PD/TX2_P: J501.B3 (TX2-), U501.19 (B0P), U503.1 (D1+), U503.10 (NC)
/Target ports/Target 2/USB-C data and PD/TX_N: C502.2, U501.3 (A0P)
/Target ports/Target 2/USB-C data and PD/TX_P: C501.2, U501.4 (A0N)
/Target ports/Target 2/USB-C data and PD/USB2_D_CONN_N: J501.A7 (D-), J501.B7 (D-), U504.2 (C_SBU2)
/Target ports/Target 2/USB-C data and PD/USB2_D_CONN_P: J501.A6 (D+), J501.B6 (D+), U504.1 (C_SBU1)
/Target ports/Target 2/USB-C data and PD/VBIAS: C505.1, U504.3 (VBIAS)
/Target ports/Target 3/USB-C data and PD/CC1_CONN: J601.A5 (CC1), U604.4 (C_CC1)
/Target ports/Target 3/USB-C data and PD/CC1_PD: C606.1, U604.12 (CC1), U605.10 (CC1), U605.11 (CC1)
/Target ports/Target 3/USB-C data and PD/CC2_CONN: J601.B5 (CC2), U604.5 (C_CC2)
/Target ports/Target 3/USB-C data and PD/CC2_PD: C607.1, U604.11 (CC2), U605.1 (CC2), U605.14 (CC2)
/Target ports/Target 3/USB-C data and PD/RX1_N: J601.B10 (RX1-), U601.12 (C1N), U602.5 (D2-), U602.6 (NC)
/Target ports/Target 3/USB-C data and PD/RX1_P: J601.B11 (RX1+), U601.13 (C1P), U602.4 (D2+), U602.7 (NC)
/Target ports/Target 3/USB-C data and PD/RX2_N: J601.A10 (RX2-), U601.16 (B1N), U603.5 (D2-), U603.6 (NC)
/Target ports/Target 3/USB-C data and PD/RX2_P: J601.A11 (RX2+), U601.17 (B1P), U603.4 (D2+), U603.7 (NC)
/Target ports/Target 3/USB-C data and PD/TX1_N: J601.A2 (TX1+), U601.14 (C0N), U602.2 (D1-), U602.9 (NC)
/Target ports/Target 3/USB-C data and PD/TX1_P: J601.A3 (TX1-), U601.15 (C0P), U602.1 (D1+), U602.10 (NC)
/Target ports/Target 3/USB-C data and PD/TX2_N: J601.B2 (TX2+), U601.18 (B0N), U603.2 (D1-), U603.9 (NC)
/Target ports/Target 3/USB-C data and PD/TX2_P: J601.B3 (TX2-), U601.19 (B0P), U603.1 (D1+), U603.10 (NC)
/Target ports/Target 3/USB-C data and PD/TX_N: C602.2, U601.3 (A0P)
/Target ports/Target 3/USB-C data and PD/TX_P: C601.2, U601.4 (A0N)
/Target ports/Target 3/USB-C data and PD/USB2_D_CONN_N: J601.A7 (D-), J601.B7 (D-), U604.2 (C_SBU2)
/Target ports/Target 3/USB-C data and PD/USB2_D_CONN_P: J601.A6 (D+), J601.B6 (D+), U604.1 (C_SBU1)
/Target ports/Target 3/USB-C data and PD/VBIAS: C605.1, U604.3 (VBIAS)
/Target ports/Target 4/USB-C data and PD/CC1_CONN: J701.A5 (CC1), U704.4 (C_CC1)
/Target ports/Target 4/USB-C data and PD/CC1_PD: C706.1, U704.12 (CC1), U705.10 (CC1), U705.11 (CC1)
/Target ports/Target 4/USB-C data and PD/CC2_CONN: J701.B5 (CC2), U704.5 (C_CC2)
/Target ports/Target 4/USB-C data and PD/CC2_PD: C707.1, U704.11 (CC2), U705.1 (CC2), U705.14 (CC2)
/Target ports/Target 4/USB-C data and PD/RX1_N: J701.B10 (RX1-), U701.12 (C1N), U702.5 (D2-), U702.6 (NC)
/Target ports/Target 4/USB-C data and PD/RX1_P: J701.B11 (RX1+), U701.13 (C1P), U702.4 (D2+), U702.7 (NC)
/Target ports/Target 4/USB-C data and PD/RX2_N: J701.A10 (RX2-), U701.16 (B1N), U703.5 (D2-), U703.6 (NC)
/Target ports/Target 4/USB-C data and PD/RX2_P: J701.A11 (RX2+), U701.17 (B1P), U703.4 (D2+), U703.7 (NC)
/Target ports/Target 4/USB-C data and PD/TX1_N: J701.A2 (TX1+), U701.14 (C0N), U702.2 (D1-), U702.9 (NC)
/Target ports/Target 4/USB-C data and PD/TX1_P: J701.A3 (TX1-), U701.15 (C0P), U702.1 (D1+), U702.10 (NC)
/Target ports/Target 4/USB-C data and PD/TX2_N: J701.B2 (TX2+), U701.18 (B0N), U703.2 (D1-), U703.9 (NC)
/Target ports/Target 4/USB-C data and PD/TX2_P: J701.B3 (TX2-), U701.19 (B0P), U703.1 (D1+), U703.10 (NC)
/Target ports/Target 4/USB-C data and PD/TX_N: C702.2, U701.3 (A0P)
/Target ports/Target 4/USB-C data and PD/TX_P: C701.2, U701.4 (A0N)
/Target ports/Target 4/USB-C data and PD/USB2_D_CONN_N: J701.A7 (D-), J701.B7 (D-), U704.2 (C_SBU2)
/Target ports/Target 4/USB-C data and PD/USB2_D_CONN_P: J701.A6 (D+), J701.B6 (D+), U704.1 (C_SBU1)
/Target ports/Target 4/USB-C data and PD/VBIAS: C705.1, U704.3 (VBIAS)
/Target ports/Target 5/USB-C data and PD/CC1_CONN: J801.A5 (CC1), U804.4 (C_CC1)
/Target ports/Target 5/USB-C data and PD/CC1_PD: C806.1, U804.12 (CC1), U805.10 (CC1), U805.11 (CC1)
/Target ports/Target 5/USB-C data and PD/CC2_CONN: J801.B5 (CC2), U804.5 (C_CC2)
/Target ports/Target 5/USB-C data and PD/CC2_PD: C807.1, U804.11 (CC2), U805.1 (CC2), U805.14 (CC2)
/Target ports/Target 5/USB-C data and PD/RX1_N: J801.B10 (RX1-), U801.12 (C1N), U802.5 (D2-), U802.6 (NC)
/Target ports/Target 5/USB-C data and PD/RX1_P: J801.B11 (RX1+), U801.13 (C1P), U802.4 (D2+), U802.7 (NC)
/Target ports/Target 5/USB-C data and PD/RX2_N: J801.A10 (RX2-), U801.16 (B1N), U803.5 (D2-), U803.6 (NC)
/Target ports/Target 5/USB-C data and PD/RX2_P: J801.A11 (RX2+), U801.17 (B1P), U803.4 (D2+), U803.7 (NC)
/Target ports/Target 5/USB-C data and PD/TX1_N: J801.A2 (TX1+), U801.14 (C0N), U802.2 (D1-), U802.9 (NC)
/Target ports/Target 5/USB-C data and PD/TX1_P: J801.A3 (TX1-), U801.15 (C0P), U802.1 (D1+), U802.10 (NC)
/Target ports/Target 5/USB-C data and PD/TX2_N: J801.B2 (TX2+), U801.18 (B0N), U803.2 (D1-), U803.9 (NC)
/Target ports/Target 5/USB-C data and PD/TX2_P: J801.B3 (TX2-), U801.19 (B0P), U803.1 (D1+), U803.10 (NC)
/Target ports/Target 5/USB-C data and PD/TX_N: C802.2, U801.3 (A0P)
/Target ports/Target 5/USB-C data and PD/TX_P: C801.2, U801.4 (A0N)
/Target ports/Target 5/USB-C data and PD/USB2_D_CONN_N: J801.A7 (D-), J801.B7 (D-), U804.2 (C_SBU2)
/Target ports/Target 5/USB-C data and PD/USB2_D_CONN_P: J801.A6 (D+), J801.B6 (D+), U804.1 (C_SBU1)
/Target ports/Target 5/USB-C data and PD/VBIAS: C805.1, U804.3 (VBIAS)
GND: C503.2, C504.2, C505.2, C506.2, C507.2, C508.2, C509.2, C510.2, C511.2, C603.2, C604.2, C605.2, C606.2, C607.2, C608.2, C609.2, C610.2, C611.2, C703.2, C704.2, C705.2, C706.2, C707.2, C708.2, C709.2, C710.2, C711.2, C803.2, C804.2, C805.2, C806.2, C807.2, C808.2, C809.2, C810.2, C811.2, J501.A1 (GND), J501.A12 (GND), J501.B1 (GND), J501.B12 (GND), J501.SH (SHIELD), J601.A1 (GND), J601.A12 (GND), J601.B1 (GND), J601.B12 (GND), J601.SH (SHIELD), J701.A1 (GND), J701.A12 (GND), J701.B1 (GND), J701.B12 (GND), J701.SH (SHIELD), J801.A1 (GND), J801.A12 (GND), J801.B1 (GND), J801.B12 (GND), J801.SH (SHIELD), U501.2 (OE_N), U501.5 (GND), U501.11 (GND), U501.20 (GND), U501.21 (EP), U502.3 (GND), U502.8 (GND), U503.3 (GND), U503.8 (GND), U504.6 (RPD_G2), U504.7 (RPD_G1), U504.8 (GND), U504.13 (GND), U504.16 (GND), U504.17 (GND), U504.18 (GND), U504.19 (D2), U504.20 (D1), U504.21 (GND), U505.8 (GND), U505.9 (GND), U505.15 (GND), U601.2 (OE_N), U601.5 (GND), U601.11 (GND), U601.20 (GND), U601.21 (EP), U602.3 (GND), U602.8 (GND), U603.3 (GND), U603.8 (GND), U604.6 (RPD_G2), U604.7 (RPD_G1), U604.8 (GND), U604.13 (GND), U604.16 (GND), U604.17 (GND), U604.18 (GND), U604.19 (D2), U604.20 (D1), U604.21 (GND), U605.8 (GND), U605.9 (GND), U605.15 (GND), U701.2 (OE_N), U701.5 (GND), U701.11 (GND), U701.20 (GND), U701.21 (EP), U702.3 (GND), U702.8 (GND), U703.3 (GND), U703.8 (GND), U704.6 (RPD_G2), U704.7 (RPD_G1), U704.8 (GND), U704.13 (GND), U704.16 (GND), U704.17 (GND), U704.18 (GND), U704.19 (D2), U704.20 (D1), U704.21 (GND), U705.8 (GND), U705.9 (GND), U705.15 (GND), U801.2 (OE_N), U801.5 (GND), U801.11 (GND), U801.20 (GND), U801.21 (EP), U802.3 (GND), U802.8 (GND), U803.3 (GND), U803.8 (GND), U804.6 (RPD_G2), U804.7 (RPD_G1), U804.8 (GND), U804.13 (GND), U804.16 (GND), U804.17 (GND), U804.18 (GND), U804.19 (D2), U804.20 (D1), U804.21 (GND), U805.8 (GND), U805.9 (GND), U805.15 (GND); also elsewhere on the board
P2_CC_FAULT_N: R502.2, U504.9 (~FLT); also elsewhere on the board
P2_ORIENTATION: R501.2, U501.9 (SEL); also elsewhere on the board
P2_PD_IRQ_N: R503.2, U505.5 (INT_N); also elsewhere on the board
P2_RX_N: U501.7 (A1P); also elsewhere on the board
P2_RX_P: U501.8 (A1N); also elsewhere on the board
P2_SCL: R504.2, U505.6 (SCL); also elsewhere on the board
P2_SDA: R505.2, U505.7 (SDA); also elsewhere on the board
P2_TX_RAW_N: C502.1; also elsewhere on the board
P2_TX_RAW_P: C501.1; also elsewhere on the board
P2_USB2_D_N: U504.14 (SBU2); also elsewhere on the board
P2_USB2_D_P: U504.15 (SBU1); also elsewhere on the board
P2_VBUS: J501.A4 (VBUS), J501.A9 (VBUS), J501.B4 (VBUS), J501.B9 (VBUS), U505.2 (VBUS); also elsewhere on the board
P3_CC_FAULT_N: R602.2, U604.9 (~FLT); also elsewhere on the board
P3_ORIENTATION: R601.2, U601.9 (SEL); also elsewhere on the board
P3_PD_IRQ_N: R603.2, U605.5 (INT_N); also elsewhere on the board
P3_RX_N: U601.7 (A1P); also elsewhere on the board
P3_RX_P: U601.8 (A1N); also elsewhere on the board
P3_SCL: R604.2, U605.6 (SCL); also elsewhere on the board
P3_SDA: R605.2, U605.7 (SDA); also elsewhere on the board
P3_TX_RAW_N: C602.1; also elsewhere on the board
P3_TX_RAW_P: C601.1; also elsewhere on the board
P3_USB2_D_N: U604.14 (SBU2); also elsewhere on the board
P3_USB2_D_P: U604.15 (SBU1); also elsewhere on the board
P3_VBUS: J601.A4 (VBUS), J601.A9 (VBUS), J601.B4 (VBUS), J601.B9 (VBUS), U605.2 (VBUS); also elsewhere on the board
P4_CC_FAULT_N: R702.2, U704.9 (~FLT); also elsewhere on the board
P4_ORIENTATION: R701.2, U701.9 (SEL); also elsewhere on the board
P4_PD_IRQ_N: R703.2, U705.5 (INT_N); also elsewhere on the board
P4_RX_N: U701.7 (A1P); also elsewhere on the board
P4_RX_P: U701.8 (A1N); also elsewhere on the board
P4_SCL: R704.2, U705.6 (SCL); also elsewhere on the board
P4_SDA: R705.2, U705.7 (SDA); also elsewhere on the board
P4_TX_RAW_N: C702.1; also elsewhere on the board
P4_TX_RAW_P: C701.1; also elsewhere on the board
P4_USB2_D_N: U704.14 (SBU2); also elsewhere on the board
P4_USB2_D_P: U704.15 (SBU1); also elsewhere on the board
P4_VBUS: J701.A4 (VBUS), J701.A9 (VBUS), J701.B4 (VBUS), J701.B9 (VBUS), U705.2 (VBUS); also elsewhere on the board
P5_CC_FAULT_N: R802.2, U804.9 (~FLT); also elsewhere on the board
P5_ORIENTATION: R801.2, U801.9 (SEL); also elsewhere on the board
P5_PD_IRQ_N: R803.2, U805.5 (INT_N); also elsewhere on the board
P5_RX_N: U801.7 (A1P); also elsewhere on the board
P5_RX_P: U801.8 (A1N); also elsewhere on the board
P5_SCL: R804.2, U805.6 (SCL); also elsewhere on the board
P5_SDA: R805.2, U805.7 (SDA); also elsewhere on the board
P5_TX_RAW_N: C802.1; also elsewhere on the board
P5_TX_RAW_P: C801.1; also elsewhere on the board
P5_USB2_D_N: U804.14 (SBU2); also elsewhere on the board
P5_USB2_D_P: U804.15 (SBU1); also elsewhere on the board
P5_VBUS: J801.A4 (VBUS), J801.A9 (VBUS), J801.B4 (VBUS), J801.B9 (VBUS), U805.2 (VBUS); also elsewhere on the board

Notes on the sheet:
CC / USB 2 protection
PD supply bypass
USB-C data and PD
USB 3 orientation
PD controller
SEL=1: CC1 / TX1 / RX1. SEL=0: CC2 / TX2 / RX2.
USB-C target
SuperSpeed ESD
Route through both pads of each ESD channel at the connector. Ground unused Dx / RPD_Gx. SBU switches protect USB 2. CC_FAULT_N directly inhibits the output switch.
Mux A-port P/N and receptacle TX1/TX2 are intentionally swapped. USB 3 receivers correct lane polarity. One AC capacitor per hub TX.

Schematic: target-power.kicad_sch, Target output — common host branch, gating and discharge

Parts:
C1216: 100n; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
C1217: 1n 50V C0G; C_0402_1005Metric; MPN FN15N102J500PNG; LCSC C525198
C1218: 2.2u 25V X5R; C_0603_1608Metric; MPN CL10A225KA8NNNC; LCSC C57895
C1219, C1220: 100n 50V X7R; C_0402_1005Metric; MPN CL05B104KB54PNC; LCSC C307331
Q1221: 2N7002; SOT-23; MPN 2N7002; LCSC C8545
R1209, R1214, R1215, R1221, R1223: 100k; R_0402_1005Metric; MPN 0402WGF1003TCE; LCSC C25741
R1210: 10k; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
R1211: 39k 1%; R_0402_1005Metric; MPN 0402WGF3902TCE; LCSC C25783
R1212: 10k 1%; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
R1213: 6.49k 1%; R_0402_1005Metric; MPN RC0402FR-076K49L; LCSC C364360
R1222: 1k 1%; R_0805_2012Metric; MPN 0805W8F1001T5E; LCSC C17513
U1202: TPS259470ARPWR; TI_RPW0010A; MPN TPS259470ARPWR; LCSC C3662799
U1203: 74LVC2G08DC-Q100H; VSSOP-8_2.3x2mm_P0.5mm; MPN 74LVC2G08DC-Q100H; LCSC C548572

Connections:
3V3_AON: C1216.1, R1210.1, U1203.8 (VCC); also elsewhere on the board
/Target ports/Target 1/Output and charging/CHARGE_EN: U1203.3; also elsewhere on the board
/Target ports/Target 1/Output and charging/HOST_DVDT: C1217.1, U1202.7 (DVDT)
/Target ports/Target 1/Output and charging/HOST_EN: R1215.1, U1202.1 (EN_UVLO), U1203.7
/Target ports/Target 1/Output and charging/HOST_ILIM: R1213.1, U1202.9 (ILM)
/Target ports/Target 1/Output and charging/HOST_OVLO: R1211.2, R1212.1, U1202.2 (OVLO)
GND: C1216.2, C1217.2, C1218.2, C1219.2, C1220.2, Q1221.2 (S), R1209.2, R1212.2, R1213.2, R1214.2, R1215.2, R1221.2, R1223.2, U1202.8 (GND), U1203.4 (GND); also elsewhere on the board
HOST_TARGET_5V: C1220.1, R1211.1, U1202.5 (IN); also elsewhere on the board
unnamed: Q1221.3 (D), R1222.2
P1_CC_FAULT_N: U1203.2, U1203.6; also elsewhere on the board
P1_CHARGE_EN_REQ: R1221.1, U1203.5; also elsewhere on the board
P1_DISCHARGE: Q1221.1 (G), R1223.1; also elsewhere on the board
P1_HOST_EN_REQ: R1209.1, U1203.1; also elsewhere on the board
P1_POWER_FAULT_N: R1210.2, U1202.4 (FLT_N); also elsewhere on the board
P1_VBUS: C1218.1, C1219.1, R1214.1, R1222.1, U1202.6 (OUT); also elsewhere on the board

Parts of its further copies:
C1316, C1416, C1516, C1616: 100n; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
C1317, C1417, C1517, C1617: 1n 50V C0G; C_0402_1005Metric; MPN FN15N102J500PNG; LCSC C525198
C1318, C1418, C1518, C1618: 2.2u 25V X5R; C_0603_1608Metric; MPN CL10A225KA8NNNC; LCSC C57895
C1319, C1320, C1419, C1420, C1519, C1520, C1619, C1620: 100n 50V X7R; C_0402_1005Metric; MPN CL05B104KB54PNC; LCSC C307331
Q1321, Q1421, Q1521, Q1621: 2N7002; SOT-23; MPN 2N7002; LCSC C8545
R1309, R1314, R1315, R1321, R1323, R1409, R1414, R1415, R1421, R1423, R1509, R1514, R1515, R1521, R1523, R1609, R1614, R1615, R1621, R1623: 100k; R_0402_1005Metric; MPN 0402WGF1003TCE; LCSC C25741
R1310, R1410, R1510, R1610: 10k; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
R1311, R1411, R1511, R1611: 39k 1%; R_0402_1005Metric; MPN 0402WGF3902TCE; LCSC C25783
R1312, R1412, R1512, R1612: 10k 1%; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
R1313, R1413, R1513, R1613: 6.49k 1%; R_0402_1005Metric; MPN RC0402FR-076K49L; LCSC C364360
R1322, R1422, R1522, R1622: 1k 1%; R_0805_2012Metric; MPN 0805W8F1001T5E; LCSC C17513
U1302, U1402, U1502, U1602: TPS259470ARPWR; TI_RPW0010A; MPN TPS259470ARPWR; LCSC C3662799
U1303, U1403, U1503, U1603: 74LVC2G08DC-Q100H; VSSOP-8_2.3x2mm_P0.5mm; MPN 74LVC2G08DC-Q100H; LCSC C548572

Connections of its further copies:
3V3_AON: C1316.1, C1416.1, C1516.1, C1616.1, R1310.1, R1410.1, R1510.1, R1610.1, U1303.8 (VCC), U1403.8 (VCC), U1503.8 (VCC), U1603.8 (VCC); also elsewhere on the board
/Target ports/Target 2/Output and charging/CHARGE_EN: U1303.3; also elsewhere on the board
/Target ports/Target 2/Output and charging/HOST_DVDT: C1317.1, U1302.7 (DVDT)
/Target ports/Target 2/Output and charging/HOST_EN: R1315.1, U1302.1 (EN_UVLO), U1303.7
/Target ports/Target 2/Output and charging/HOST_ILIM: R1313.1, U1302.9 (ILM)
/Target ports/Target 2/Output and charging/HOST_OVLO: R1311.2, R1312.1, U1302.2 (OVLO)
/Target ports/Target 3/Output and charging/CHARGE_EN: U1403.3; also elsewhere on the board
/Target ports/Target 3/Output and charging/HOST_DVDT: C1417.1, U1402.7 (DVDT)
/Target ports/Target 3/Output and charging/HOST_EN: R1415.1, U1402.1 (EN_UVLO), U1403.7
/Target ports/Target 3/Output and charging/HOST_ILIM: R1413.1, U1402.9 (ILM)
/Target ports/Target 3/Output and charging/HOST_OVLO: R1411.2, R1412.1, U1402.2 (OVLO)
/Target ports/Target 4/Output and charging/CHARGE_EN: U1503.3; also elsewhere on the board
/Target ports/Target 4/Output and charging/HOST_DVDT: C1517.1, U1502.7 (DVDT)
/Target ports/Target 4/Output and charging/HOST_EN: R1515.1, U1502.1 (EN_UVLO), U1503.7
/Target ports/Target 4/Output and charging/HOST_ILIM: R1513.1, U1502.9 (ILM)
/Target ports/Target 4/Output and charging/HOST_OVLO: R1511.2, R1512.1, U1502.2 (OVLO)
/Target ports/Target 5/Output and charging/CHARGE_EN: U1603.3; also elsewhere on the board
/Target ports/Target 5/Output and charging/HOST_DVDT: C1617.1, U1602.7 (DVDT)
/Target ports/Target 5/Output and charging/HOST_EN: R1615.1, U1602.1 (EN_UVLO), U1603.7
/Target ports/Target 5/Output and charging/HOST_ILIM: R1613.1, U1602.9 (ILM)
/Target ports/Target 5/Output and charging/HOST_OVLO: R1611.2, R1612.1, U1602.2 (OVLO)
GND: C1316.2, C1317.2, C1318.2, C1319.2, C1320.2, C1416.2, C1417.2, C1418.2, C1419.2, C1420.2, C1516.2, C1517.2, C1518.2, C1519.2, C1520.2, C1616.2, C1617.2, C1618.2, C1619.2, C1620.2, Q1321.2 (S), Q1421.2 (S), Q1521.2 (S), Q1621.2 (S), R1309.2, R1312.2, R1313.2, R1314.2, R1315.2, R1321.2, R1323.2, R1409.2, R1412.2, R1413.2, R1414.2, R1415.2, R1421.2, R1423.2, R1509.2, R1512.2, R1513.2, R1514.2, R1515.2, R1521.2, R1523.2, R1609.2, R1612.2, R1613.2, R1614.2, R1615.2, R1621.2, R1623.2, U1302.8 (GND), U1303.4 (GND), U1402.8 (GND), U1403.4 (GND), U1502.8 (GND), U1503.4 (GND), U1602.8 (GND), U1603.4 (GND); also elsewhere on the board
HOST_TARGET_5V: C1320.1, C1420.1, C1520.1, C1620.1, R1311.1, R1411.1, R1511.1, R1611.1, U1302.5 (IN), U1402.5 (IN), U1502.5 (IN), U1602.5 (IN); also elsewhere on the board
unnamed: Q1321.3 (D), R1322.2
unnamed: Q1421.3 (D), R1422.2
unnamed: Q1521.3 (D), R1522.2
unnamed: Q1621.3 (D), R1622.2
P2_CC_FAULT_N: U1303.2, U1303.6; also elsewhere on the board
P2_CHARGE_EN_REQ: R1321.1, U1303.5; also elsewhere on the board
P2_DISCHARGE: Q1321.1 (G), R1323.1; also elsewhere on the board
P2_HOST_EN_REQ: R1309.1, U1303.1; also elsewhere on the board
P2_POWER_FAULT_N: R1310.2, U1302.4 (FLT_N); also elsewhere on the board
P2_VBUS: C1318.1, C1319.1, R1314.1, R1322.1, U1302.6 (OUT); also elsewhere on the board
P3_CC_FAULT_N: U1403.2, U1403.6; also elsewhere on the board
P3_CHARGE_EN_REQ: R1421.1, U1403.5; also elsewhere on the board
P3_DISCHARGE: Q1421.1 (G), R1423.1; also elsewhere on the board
P3_HOST_EN_REQ: R1409.1, U1403.1; also elsewhere on the board
P3_POWER_FAULT_N: R1410.2, U1402.4 (FLT_N); also elsewhere on the board
P3_VBUS: C1418.1, C1419.1, R1414.1, R1422.1, U1402.6 (OUT); also elsewhere on the board
P4_CC_FAULT_N: U1503.2, U1503.6; also elsewhere on the board
P4_CHARGE_EN_REQ: R1521.1, U1503.5; also elsewhere on the board
P4_DISCHARGE: Q1521.1 (G), R1523.1; also elsewhere on the board
P4_HOST_EN_REQ: R1509.1, U1503.1; also elsewhere on the board
P4_POWER_FAULT_N: R1510.2, U1502.4 (FLT_N); also elsewhere on the board
P4_VBUS: C1518.1, C1519.1, R1514.1, R1522.1, U1502.6 (OUT); also elsewhere on the board
P5_CC_FAULT_N: U1603.2, U1603.6; also elsewhere on the board
P5_CHARGE_EN_REQ: R1621.1, U1603.5; also elsewhere on the board
P5_DISCHARGE: Q1621.1 (G), R1623.1; also elsewhere on the board
P5_HOST_EN_REQ: R1609.1, U1603.1; also elsewhere on the board
P5_POWER_FAULT_N: R1610.2, U1602.4 (FLT_N); also elsewhere on the board
P5_VBUS: C1618.1, C1619.1, R1614.1, R1622.1, U1602.6 (OUT); also elsewhere on the board

Notes on the sheet:
Target output — common host branch, gating and discharge
HOST_TARGET_5V feeds a reverse-blocking switch; the charging stage joins only at VBUS.
Host branch: ~0.5 A per-port limit; the common limiter owns the total host budget. Both branches must be off before active discharge. CC protection gates both source enables in hardware. 100k remains across VBUS when all active circuitry is off.
